# Keil uVision project SWM181.uvprojx, settings and files
target SWM181 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.16.22
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplUART_Interrupt_RX
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\SWM181_StdPeriph_Driver;..\..\..\app\user;..\..\..\modules\fifo;..\..\..\modules\utils;..\..\..\os;.\user;..\drivers;..\..\SWM181xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Code
    ../Libraries/SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
  group CMSIS
    ../Libraries/SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
  group bsp
    ../drivers/: bsp.c swm181x_led.c swm181x_usart.c
  group app
    ../../../app/: main.c
    ../: config.h
  group os
    ../../../os/: cola_device.c cola_os.c cola_init.c
  group app/usr
    ../../../app/user/: app.c app_uart.c
  group modules
    ../../../modules/fifo/: cola_fifo.c
    ../../../modules/utils/: utils.c
  group Library
    ../Libraries/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cache.c SWM181_can.c SWM181_cmp.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_exti.c SWM181_flash.c SWM181_gpio.c SWM181_i2c.c SWM181_irqmux.c SWM181_port.c SWM181_pwm.c SWM181_sdadc.c SWM181_slcd.c SWM181_sleep.c SWM181_spi.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c
