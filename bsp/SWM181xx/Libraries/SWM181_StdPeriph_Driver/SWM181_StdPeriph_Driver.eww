<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SWM181_StdPeriph_Driver.ewp</path>
  </project>
  <batchBuild/>
</workspace>
