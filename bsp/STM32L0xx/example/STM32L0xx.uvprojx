# Keil uVision project STM32L0xx.uvprojx, settings and files
target Project_Name (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --gnu
  c include: ..\..\..\app;..\STM32_Cube\Inc;..\STM32_Cube\Drivers\STM32L0xx_HAL_Driver\Inc;..\STM32_Cube\Drivers\CMSIS\Include;..\STM32_Cube\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\STM32_Cube\Drivers\STM32L0xx_HAL_Driver\Src;..\drivers;..\example;..\..\..\modules\fifo;..\..\..\os;..\..\..\app\user;..\STM32_Cube\Inc;..\..\..\modules\utils;..\STM32_Cube\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\STM32L0xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ../STM32_Cube/MDK-ARM/: startup_stm32l051xx.s
  group CMSIS
    ../STM32_Cube/Src/: system_stm32l0xx.c
  group bsp
    ../drivers/: bsp.c stm32_led.c stm32_output.c stm32_sleep.c stm32_usart.c
  group app
    ../../../app/: main.c
    ../: config.h
  group os
    ../../../os/: cola_device.c cola_init.c cola_os.c
  group app/usr
    ../../../app/user/: app.c app_uart.c
  group bsp_cube
    ../STM32_Cube/Src/: gpio.c rtc.c spi.c usart.c
  group modules
    ../../../modules/fifo/: cola_fifo.c
    ../../../modules/utils/: utils.c
  group Library
    ../STM32_Cube/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_crc.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_cortex.c
    ../STM32_Cube/Src/: stm32l0xx_hal_msp.c
