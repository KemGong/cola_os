# Keil uVision project STM32F0xx.uvprojx, settings and files
target Project_Name (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\app;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\startup;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\drivers;..\..\STM32F0xx;..\..\..\module;..\..\..\os;..\..\..\app\user;..\..\..\modules\fifo;..\..\..\modules\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup Code
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f030.s
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f0xx.c
  group bsp
    ../drivers/: bsp.c stm32_led.c stm32_output.c stm32_usart.c
  group app
    ../../../app/: main.c
    ../: config.h
  group Library
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group os
    ../../../os/: cola_device.c cola_init.c cola_os.c
  group app/usr
    ../../../app/user/: app.c app_uart.c
  group modules
    ../../../modules/fifo/: cola_fifo.c
    ../../../modules/utils/: utils.c
