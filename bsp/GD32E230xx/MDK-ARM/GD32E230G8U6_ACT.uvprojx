# Keil uVision project GD32E230G8U6_ACT.uvprojx, settings and files
target GD32E230G8U6_ACT (6160000::V6.16::ARMCLANG)
  device: GD32E230F8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Object +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\GD32E23x_Firmware_Library\CMSIS;..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\;..\Soft_Drive;..\app_iap;..\aaplication;..\..\..\app;..\drivers;..\..\..\modules;..\..\..\os;..\..\..\app\user;..\..\..\modules\fifo;..\..\..\modules\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Bsp
    ../drivers/: bsp.c gd32_usart.c gd32_output.c gd32_adc.c
  group App
    ../../../app/: main.c
    ../: config.h
    ../../../app/user/: app_water_detection.c
  group OS
    ../../../os/: cola_device.c cola_init.c cola_os.c
  group app/usr
    ../../../app/user/: app.c app_uart.c
  group modules
    ../../../modules/fifo/: cola_fifo.c
    ../../../modules/utils/: utils.c
software components: CMSIS:CORE 5.5.0
